FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://perf_fixes.scc"
